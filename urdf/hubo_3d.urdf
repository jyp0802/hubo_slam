Commit message: Update HUBO URDF with more accurate measurements

File: urdf/hubo_3d.urdf (robot description, URDF)
Before this commit: robot hubo_3d, 3 links, 2 joints
Joints:
- joint vlp16_link_joint: origin xyz=0. 0. 0.015 rpy=0. 0. 0. -> xyz=0. 0. 0.013 rpy=0. 0. 0.
